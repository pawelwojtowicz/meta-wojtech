FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://usb-serial-for-LTE.cfg \
            file://usb-serial-acm.cfg \
            file://rpi2soundcard.cfg "
