FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://usb-serial-for-LTE.cfg"
